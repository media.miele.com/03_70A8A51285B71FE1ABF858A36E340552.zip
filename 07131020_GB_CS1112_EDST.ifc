Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 78952d03-5dc2-4f1b-b7f0-5430962a5c0e, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-07T13:53:48+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 07131020_GB_CS1112_EDST:27111250_GB_7131020_CS1112_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, Default, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 288 mm; Height: 73 mm; Depth: 520 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 27111250_GB_7131020_CS1112_EDST; sets with these values: 2
